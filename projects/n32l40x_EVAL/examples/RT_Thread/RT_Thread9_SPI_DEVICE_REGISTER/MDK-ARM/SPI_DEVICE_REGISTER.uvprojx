# Keil uVision project SPI_DEVICE_REGISTER.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI_DEVICE_REGISTER
  AfterMake: fromelf --bin --output=.\bin\SPI_DEVICE_REGISTER.bin .\Objects\SPI_DEVICE_REGISTER.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\spi\sfud\inc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\spi;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\uart\inc;..\..\DeviceDrivers\spi\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_exti.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_spi.c n32l40x_usart.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group USER
    ../src/: board.c main.c n32l40x_it.c spi_flash_w25q.c
  group Device_Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../../../../middlewares/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
    ../../DeviceDrivers/spi/src/: drv_spi.c
  group DOC
    ../: readme.txt
