# Keil uVision project RCC_ClockConfig.uvprojx, settings and files
target N32L40x (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RCC_ClockConfig +hex
  AfterMake: fromelf --bin --output=.\bin\RCC_ClockConfig.bin .\Objects\RCC_ClockConfig.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\N32L40x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_N32L40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_N32L40x.c
  group FWLB
    ../../../../../../firmware/N32L40x_std_periph_driver/src/: misc.c N32L40x_flash.c N32L40x_gpio.c N32L40x_pwr.c N32L40x_rcc.c N32L40x_usart.c
  group USER
    ../src/: main.c N32L40x_it.c
  group BSP
    ../../../../bsp/src/: log.c
