# Keil uVision project TSC.uvprojx, settings and files
target N32L40x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TSC_SW +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group Driver
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_tim.c n32l40x_tsc.c n32l40x_usart.c n32l40x_pwr.c
  group User
    ../src/: main.c delay.c n32l40x_it.c
  group Bsp
    ../src/: bsp_tsc.c bsp_timer.c bsp_gpio.c bsp_usart.c
  group DOC
    ../: readme.txt
