# IAR project TSC.ewp, settings and files
configuration N32L40x (ARM, debug)
  General.OGChipSelectEditMenu: N32L406MB Nations N32L406MB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/n32l40x_std_periph_driver/inc; ../../../../../../firmware/CMSIS/device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Bsp
    ../src/: bsp_gpio.c bsp_timer.c bsp_tsc.c bsp_usart.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group DOC
    ../: readme.txt
  group Driver
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_tim.c n32l40x_tsc.c n32l40x_usart.c
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group User
    ../src/: delay.c main.c n32l40x_it.c
