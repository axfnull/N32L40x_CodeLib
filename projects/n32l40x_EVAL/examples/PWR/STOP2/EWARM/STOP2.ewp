# IAR project STOP2.ewp, settings and files
configuration N32L40x (ARM, debug)
  General.OGChipSelectEditMenu: N32L406MB Nations N32L406MB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32l40x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STOP2.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_tsc.c n32l40x_usart.c n32l40x_wwdg.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group USER
    ../src/: main.c n32l40x_it.c User_Key_Config.c User_LED_Config.c User_Sysclock_Config.c
